options:
  parameters:
    author: garw
    generate_options: qt_gui
    id: narrowband_inspect
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 56e2
  states: {}
- name: analog_fastnoise_source_x_1
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: float
    vlen: '64'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: inspector_signal_detector_cvf_0
  id: inspector_signal_detector_cvf
  parameters:
    auto: 'True'
    avg: '0.8'
    fft_len: '64'
    logfile: ''
    min_bw: '0'
    quant: '0.001'
    samp_rate: samp_rate
    sensitivity: '0.6'
    threshold: '0.7'
    window: window.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '64'
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: sig53_new_narrowband_0
  id: sig53_new_narrowband
  parameters:
    class_name: 1024qam
    dataset_length: 1024 * 60
    fft_size: '1024'
    impairment_level: '0'
    repeat: 'True'
    sample_rate: samp_rate
    vlen: '1'
  states: {state: disabled}

connections:
- [analog_fastnoise_source_x_1, '0', blocks_throttle2_0, '0']
- [analog_fastnoise_source_x_1, '0', inspector_signal_detector_cvf_0, '0']
- [inspector_signal_detector_cvf_0, '0', blocks_tag_debug_0, '0']
- [inspector_signal_detector_cvf_0, '0', qtgui_vector_sink_f_0, '0']
- [inspector_signal_detector_cvf_0, map_out, blocks_message_debug_0, log]
- [sig53_new_narrowband_0, '0', blocks_throttle2_0, '0']
- [sig53_new_narrowband_0, '0', inspector_signal_detector_cvf_0, '0']
- [sig53_new_narrowband_0, datasetLabel, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
