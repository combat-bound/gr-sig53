options:
  parameters:
    author: Opensource at Combat Bound
    copyright: Combat Bound, LLC
    generate_options: qt_gui
    id: sig53_gen_example
    max_nouts: '100000'
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    ignoretag: 'False'
    samples_per_second: samp_rate
    type: complex
    vlen: 1024 * 1024
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: 1024 * 1024
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: sig53_new_narrowband_0
  id: sig53_new_narrowband
  parameters:
    class_name: 16qam
    dataset_length: 1024 * 1024
    fft_size: '1024'
    impairment_level: '1'
    repeat: 'True'
    sample_rate: samp_rate
    vlen: 1024 * 1024
  states: {}
- name: spectrumDetect_specDetect_0
  id: spectrumDetect_specDetect
  parameters:
    center_frequency: 2.5e6
    detect_json: 'True'
    gpu_device: cpu
    gpu_half: 'False'
    n_fft: '1024'
    sample_rate: samp_rate
    trained_narrowband_model: /opt/torchsig/v1.1.0/xcit.ckpt
    trained_wideband_model: /opt/torchsig/v1.1.0/11s.pt
    vector_size: 1024 * 1024
    wb_detect_only: 'True'
    write_labeled_wb_images: 'False'
    write_nb_iq_file: 'False'
    write_wb_images: 'False'
    write_wb_iq_file: 'False'
    yolo_agnostic_nms: 'False'
    yolo_augment: 'False'
    yolo_conf: '0.25'
    yolo_iou: '0.7'
    yolo_max_det: '300'
  states: {}
- name: spectrumDetect_spectrumPlot_0
  id: spectrumDetect_spectrumPlot
  parameters:
    label: ''
    save: 'True'
  states: {}

connections:
- [blocks_throttle2_1, '0', spectrumDetect_specDetect_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_waterfall_sink_x_0, '0']
- [sig53_new_narrowband_0, '0', blocks_throttle2_1, '0']
- [sig53_new_narrowband_0, '0', blocks_vector_to_stream_0, '0']
- [sig53_new_narrowband_0, datasetLabel, blocks_message_debug_0, print]
- [spectrumDetect_specDetect_0, detect_pmt, spectrumDetect_spectrumPlot_0, detect_pmt]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
